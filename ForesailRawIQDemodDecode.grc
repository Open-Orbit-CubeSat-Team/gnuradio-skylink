options:
  parameters:
    generate_options: qt_gui
    id: ForesailRawIQDemodDecode
    output_language: python
    title: ForesailIQ - Skylink - Sample Demod
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: tune_shift
  id: variable_qtgui_range
  parameters:
    start: '-50000'
    step: '1'
    stop: '50000'
    value: '0'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '5'
    max_gain: '65536'
    reference: '1'
    type: complex
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '2'
    rate: '0.001'
    reference: '1.0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '13'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/groundstation-user/GS1/Foresail1P_NightOps/Foresail_4_18.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '250'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.076'
    gain_omega: '0.0016'
    mu: '0.5'
    omega: '10'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import os
      import zlib
      import numpy as np
      from gnuradio import gr

      try:
          import reed_solomon_ccsds as _rs_lib
          _RS_AVAILABLE = True
      except ImportError:
          _RS_AVAILABLE = False
          print("[WARN] reed-solomon-ccsds not installed — RS correction disabled.")


      # ── Golay(24,12) ─────────────────────────────────────────────────────────────
      _G_N = 12
      _G_H = (
          0x8008ed, 0x4001db, 0x2003b5, 0x100769, 0x80ed1, 0x40da3,
          0x20b47, 0x1068f, 0x8D1D, 0x4A3B, 0x2477, 0x1FFE
      )


      def _parity(v: int) -> int:
          v ^= v >> 16
          v ^= v >> 8
          v ^= v >> 4
          return (0x6996 >> (v & 0xF)) & 1


      def _popcount(i: int) -> int:
          i -= (i >> 1) & 0x55555555
          i = (i & 0x33333333) + ((i >> 2) & 0x33333333)
          return (((i + (i >> 4)) & 0x0F0F0F0F) * 0x01010101) >> 24


      class GolayUncorrectable(Exception):
          pass


      def _golay24_decode(word: int):
          def syndrome(w):
              return sum(_parity(_G_H[i] & w) << (_G_N - 1 - i) for i in range(_G_N))

          s = syndrome(word)
          if _popcount(s) <= 3:
              e = s << _G_N
          else:
              e = next(
                  (
                      ((s ^ (_G_H[i] & 0xFFF)) << _G_N) | (1 << (_G_N - i - 1))
                      for i in range(_G_N)
                      if _popcount(s ^ (_G_H[i] & 0xFFF)) <= 2
                  ),
                  None,
              )
              if e is None:
                  q = syndrome(s)
                  if _popcount(q) <= 3:
                      e = q
                  else:
                      e = next(
                          (
                              (1 << (2 * _G_N - i - 1)) | (q ^ (_G_H[i] & 0xFFF))
                              for i in range(_G_N)
                              if _popcount(q ^ (_G_H[i] & 0xFFF)) <= 2
                          ),
                          None,
                      )
                      if e is None:
                          raise GolayUncorrectable()

          return (word ^ e) & 0xFFF, _popcount(e)


      # ── RS decoder ───────────────────────────────────────────────────────────────
      class RSDecoder:
          RS_PARITY = 32
          RS_DATA = 223

          def __init__(self):
              self.ok = _RS_AVAILABLE

          def decode(self, de_cw: bytes, data_len: int):
              if not self.ok:
                  return de_cw[:data_len], 0, None

              n_virt = self.RS_DATA - data_len
              block = np.zeros(255, dtype=np.uint8)

              block[n_virt:self.RS_DATA] = np.frombuffer(de_cw[:data_len], dtype=np.uint8)
              block[self.RS_DATA:] = np.frombuffer(
                  de_cw[data_len:data_len + self.RS_PARITY], dtype=np.uint8
              )

              try:
                  n_errs, decoded = _rs_lib.decode_block(block, dual_basis=False)
                  recovered = bytes(decoded[n_virt:self.RS_DATA])
                  return recovered, int(n_errs), True
              except _rs_lib.UncorrectableError:
                  return de_cw[:data_len], 0, False


      # ── Embedded Python Block ────────────────────────────────────────────────────
      class blk(gr.sync_block):
          """
          SDR-side frame recovery only.
          Writes:
            clean_frames.bin  -> [2-byte len][frame bytes]...
            clean_frames.hex  -> one frame hex per line
          """

          ASM = 0x1ACFFC1D
          ASM_LEN = 32
          GOLAY_LEN = 24
          CW_BYTES = 255
          CW_BITS = CW_BYTES * 8
          RS_BYTES = 32
          DAT_BYTES = 223
          ASM_MAX_ERR = 4
          MAGIC = b"fOH2F1S"

          def __init__(self, out_dir="/tmp/skylink_out", debug=False):
              gr.sync_block.__init__(
                  self,
                  name="Skylink Frame Recovery",
                  in_sig=[np.uint8],
                  out_sig=[]
              )

              self.out_dir = str(out_dir)
              self.debug = bool(debug)
              os.makedirs(self.out_dir, exist_ok=True)

              self.bin_path = os.path.join(self.out_dir, "clean_frames.bin")
              self.hex_path = os.path.join(self.out_dir, "clean_frames.hex")

              self._bin_f = open(self.bin_path, "wb")
              self._hex_f = open(self.hex_path, "w", encoding="utf-8")

              self._asm_bits = [(self.ASM >> b) & 1 for b in reversed(range(32))]
              self._ks = self._build_keystream(self.CW_BYTES)
              self._rs = RSDecoder()

              self._buf = []
              self._abs0 = 0
              self._search_abs = 0
              self._seen = set()

              self._candidate_count = 0
              self._emit_count = 0
              self._rs_ok_count = 0
              self._rs_fixed_count = 0
              self._rs_fail_count = 0

          @staticmethod
          def _build_keystream(n):
              reg, out = 0xFF, bytearray(n)
              for bi in range(n):
                  v = 0
                  for _ in range(8):
                      v = (v << 1) | (reg >> 7)
                      fb = ((reg >> 7) ^ (reg >> 4) ^ (reg >> 2) ^ reg) & 1
                      reg = ((reg << 1) & 0xFF) | fb
                  out[bi] = v
              return bytes(out)

          def _dewhiten(self, raw: bytes) -> bytes:
              return bytes(b ^ k for b, k in zip(raw, self._ks))

          def _asm_dist(self, bits) -> int:
              return sum(a != b for a, b in zip(bits, self._asm_bits))

          def _find_asm(self, start: int) -> int:
              limit = len(self._buf) - (self.ASM_LEN + self.GOLAY_LEN + self.CW_BITS)
              for i in range(start, max(start, limit)):
                  if self._asm_dist(self._buf[i:i + 32]) <= self.ASM_MAX_ERR:
                      return i
              return -1

          @staticmethod
          def _pack_msb(bits) -> bytes:
              out = bytearray(len(bits) // 8)
              for j, i in enumerate(range(0, len(bits), 8)):
                  b = bits[i:i + 8]
                  out[j] = (
                      (b[0] << 7) | (b[1] << 6) | (b[2] << 5) | (b[3] << 4) |
                      (b[4] << 3) | (b[5] << 2) | (b[6] << 1) | b[7]
                  )
              return bytes(out)

          @staticmethod
          def _bits_to_int(bits) -> int:
              v = 0
              for b in bits:
                  v = (v << 1) | (b & 1)
              return v

          def _trim_buf(self):
              if len(self._buf) > 300_000:
                  drop = len(self._buf) - 300_000
                  del self._buf[:drop]
                  self._abs0 += drop
                  self._search_abs = max(self._search_abs, self._abs0)

          def _append_frame(self, asm_abs: int, frame_data: bytes):
              self._emit_count += 1
              self._bin_f.write(len(frame_data).to_bytes(2, "big") + frame_data)
              self._hex_f.write(f"{self._emit_count:04d} asm={asm_abs} {frame_data.hex()}\n")

              flags_vc = frame_data[7] if len(frame_data) > 7 else 0
              vc = flags_vc & 0x07
              seq = ((frame_data[9] << 8) | frame_data[10]) if len(frame_data) > 10 else -1

              print(
                  f"[FRAME {self._emit_count:03d}] asm={asm_abs} vc={vc} seq={seq} len={len(frame_data)}",
                  flush=True
              )

          def work(self, input_items, output_items):
              bits = input_items[0].astype(np.uint8) & 1
              if not len(bits):
                  return 0

              self._buf.extend(bits.tolist())
              self._trim_buf()

              rel = max(0, self._search_abs - self._abs0)

              while True:
                  asm_rel = self._find_asm(rel)
                  if asm_rel < 0:
                      break

                  g_start = asm_rel + self.ASM_LEN
                  c_start = g_start + self.GOLAY_LEN

                  golay_bits = self._buf[g_start:g_start + self.GOLAY_LEN]
                  cw_bits = self._buf[c_start:c_start + self.CW_BITS]

                  if len(golay_bits) < self.GOLAY_LEN or len(cw_bits) < self.CW_BITS:
                      break

                  def reject():
                      nonlocal rel
                      rel = asm_rel + 1
                      self._search_abs = self._abs0 + rel

                  golay_raw = self._bits_to_int(golay_bits)
                  try:
                      data12, _g_errs = _golay24_decode(golay_raw)
                  except GolayUncorrectable:
                      reject()
                      continue

                  data_len = data12 - self.RS_BYTES
                  if not (1 <= data_len <= self.DAT_BYTES):
                      reject()
                      continue

                  raw255 = self._pack_msb(cw_bits)
                  de255 = self._dewhiten(raw255)

                  if de255[:7] != self.MAGIC:
                      reject()
                      continue

                  if (11 + de255[8]) > self.DAT_BYTES:
                      reject()
                      continue

                  key = zlib.crc32(raw255) & 0xFFFFFFFF
                  if key in self._seen:
                      reject()
                      continue
                  self._seen.add(key)

                  de_cw = de255[:data12]

                  self._candidate_count += 1
                  rs_data, rs_errs, rs_ok = self._rs.decode(de_cw, data_len)

                  if rs_ok is False:
                      self._rs_fail_count += 1
                      frame_data = de_cw[:data_len]
                  elif rs_ok is True:
                      if rs_errs > 0:
                          self._rs_fixed_count += 1
                      else:
                          self._rs_ok_count += 1
                      frame_data = rs_data
                  else:
                      frame_data = de_cw[:data_len]

                  if frame_data[:7] != self.MAGIC:
                      reject()
                      continue

                  self._append_frame(self._abs0 + asm_rel, frame_data)
                  reject()

              return len(input_items[0])

          def stop(self):
              try:
                  self._bin_f.flush()
                  self._bin_f.close()
              except Exception:
                  pass

              try:
                  self._hex_f.flush()
                  self._hex_f.close()
              except Exception:
                  pass

              print("\n" + "═" * 62)
              print("  FRAME RECOVERY SUMMARY")
              print("─" * 62)
              print(f"  Candidates seen      : {self._candidate_count}")
              print(f"  Frames emitted       : {self._emit_count}")
              if _RS_AVAILABLE:
                  print(f"  RS clean (0 errors)  : {self._rs_ok_count}")
                  print(f"  RS corrected         : {self._rs_fixed_count}")
                  print(f"  RS uncorrectable     : {self._rs_fail_count}")
              print(f"  Binary log           : {self.bin_path}")
              print(f"  Hex text             : {self.hex_path}")
              print("═" * 62 + "\n")
              return True
    debug: 'True'
    out_dir: '''/home/sbuhrman/CubeSat/Skylink'''
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import os
      import zlib
      import numpy as np
      from gnuradio import gr

      # ── Golay(24,12) constants ────────────────────────────────────────────────────
      _G_N = 12
      _G_H = (
          0x8008ed, 0x4001db, 0x2003b5, 0x100769, 0x80ed1, 0x40da3,
          0x20b47,  0x1068f,  0x8d1d,   0x4a3b,   0x2477,  0x1ffe
      )


      def _parity(v: int) -> int:
          v ^= v >> 16
          v ^= v >> 8
          v ^= v >> 4
          return (0x6996 >> (v & 0xF)) & 1


      def _popcount(i: int) -> int:
          return int(i).bit_count()


      class GolayUncorrectable(Exception):
          pass


      def _golay24_decode(word: int) -> tuple[int, int]:
          """Decode a 24-bit Golay codeword. Returns (data12, n_errors). Raises GolayUncorrectable."""
          def syndrome(w):
              return sum(_parity(_G_H[i] & w) << (_G_N - 1 - i) for i in range(_G_N))

          s = syndrome(word)

          if _popcount(s) <= 3:
              e = s << _G_N
          else:
              e = next(
                  (
                      ((s ^ (_G_H[i] & 0xFFF)) << _G_N) | (1 << (_G_N - i - 1))
                      for i in range(_G_N)
                      if _popcount(s ^ (_G_H[i] & 0xFFF)) <= 2
                  ),
                  None
              )
              if e is None:
                  q = syndrome(s)  # second syndrome
                  if _popcount(q) <= 3:
                      e = q
                  else:
                      e = next(
                          (
                              (1 << (2 * _G_N - i - 1)) | (q ^ (_G_H[i] & 0xFFF))
                              for i in range(_G_N)
                              if _popcount(q ^ (_G_H[i] & 0xFFF)) <= 2
                          ),
                          None
                      )
                      if e is None:
                          raise GolayUncorrectable()

          corrected = (word ^ e) & 0xFFF
          return corrected, _popcount(e)


      # ── GNU Radio block ───────────────────────────────────────────────────────────

      class blk(gr.sync_block):
          """
          Skylink / FORESAIL-1 frame decoder

          Input  : unpacked bits (uint8, one bit per byte, MSB-first)
          Output : none  (frames written to <out_dir>/clean_frames.bin)

          Framing: ASM (0x1ACFFC1D, 32 bits)
                 + Golay(24,12) length field
                 + RS(255,223) CCSDS-whitened codeword

          Output file is self-delimiting: each frame prefixed with 2-byte big-endian length.
          """

          ASM         = 0x1ACFFC1D
          ASM_LEN     = 32
          GOLAY_LEN   = 24
          CW_BYTES    = 255
          RS_BYTES    = 32
          DAT_BYTES   = 223
          ASM_MAX_ERR = 3
          MAGIC       = b'fOH2F1S'

          VC_NAMES = {
              0: "VC0 Commanding",
              1: "VC1 Mass data transfer",
              2: "VC2 Service channel",
              3: "VC3 HAM repeater",
          }

          def __init__(self, out_dir="/tmp/skylink_out"):
              gr.sync_block.__init__(self, name="Skylink Frame Decoder",
                                     in_sig=[np.uint8], out_sig=[])
              self.out_dir = str(out_dir)
              os.makedirs(self.out_dir, exist_ok=True)

              self._asm_bits = [(self.ASM >> b) & 1 for b in reversed(range(32))]
              self._cw_bits  = self.CW_BYTES * 8
              self._ks       = self._build_keystream(self.CW_BYTES)

              self._buf = []
              self._abs0 = 0
              self._search_abs = 0
              self._asm_count = 0
              self._seen = set()
              self._clean_frames = []

          @staticmethod
          def _build_keystream(nbytes: int) -> bytes:
              """CCSDS PN sequence: poly x^8+x^7+x^5+x^3+1, init=0xFF."""
              reg, out = 0xFF, bytearray(nbytes)
              for bi in range(nbytes):
                  v = 0
                  for _ in range(8):
                      v   = (v << 1) | (reg >> 7)
                      fb  = ((reg >> 7) ^ (reg >> 4) ^ (reg >> 2) ^ reg) & 1
                      reg = ((reg << 1) & 0xFF) | fb
                  out[bi] = v
              return bytes(out)

          def _dewhiten(self, raw: bytes) -> bytes:
              return bytes(b ^ k for b, k in zip(raw, self._ks))

          def _asm_distance(self, bits) -> int:
              return sum(a != b for a, b in zip(bits, self._asm_bits))

          def _find_asm(self, start_rel: int) -> int:
              limit = len(self._buf) - (self.ASM_LEN + self.GOLAY_LEN + self._cw_bits)
              for i in range(start_rel, limit):
                  if self._asm_distance(self._buf[i:i + 32]) <= self.ASM_MAX_ERR:
                      return i
              return -1

          @staticmethod
          def _pack_msb(bits) -> bytes:
              out = bytearray(len(bits) // 8)
              for j, i in enumerate(range(0, len(bits), 8)):
                  b = bits[i:i+8]
                  out[j] = (
                      (b[0] << 7) | (b[1] << 6) | (b[2] << 5) | (b[3] << 4) |
                      (b[4] << 3) | (b[5] << 2) | (b[6] << 1) | b[7]
                  )
              return bytes(out)

          @staticmethod
          def _bits_to_int(bits) -> int:
              v = 0
              for b in bits:
                  v = (v << 1) | (b & 1)
              return v

          def _trim_buf(self):
              if len(self._buf) > 300_000:
                  drop = len(self._buf) - 300_000
                  del self._buf[:drop]
                  self._abs0 += drop
                  self._search_abs = max(self._search_abs, self._abs0)

          def _emit(self, de255: bytes, golay_raw: int, data12: int, n_errors: int, asm_abs: int):
              data_len    = data12 - self.RS_BYTES
              proto_id    = de255[0]
              sat_id      = de255[1:7]
              flags_vc    = de255[7]

              # Fix: VC is 2 bits, not 3
              vc          = flags_vc & 0x03

              # Keep original indexing/behavior for the rest so output stays familiar
              has_auth    = (flags_vc >> 3) & 1
              arq_on      = (flags_vc >> 4) & 1
              has_payload = (flags_vc >> 5) & 1

              ext_len     = de255[8]
              seq         = (de255[9] << 8) | de255[10]
              ext_end     = 11 + ext_len

              clean_frame = de255[:data_len]
              clean_ext   = clean_frame[11:min(ext_end, data_len)]
              after_ext   = clean_frame[ext_end:] if data_len > ext_end else b""
              clean_auth, clean_payload = (
                  (after_ext[-8:], after_ext[:-8])
                  if has_auth and len(after_ext) >= 8 else (b"", after_ext)
              )

              vc_label = self.VC_NAMES.get(vc, f"VC{vc}")

              SEP = "─" * 60
              self._asm_count += 1
              print(f"\n{'═'*60}")
              print(f"  ASM #{self._asm_count}  @ bit {asm_abs}")
              print(SEP)
              print(f"  Protocol ID : 0x{proto_id:02X}  ({'OK' if proto_id == 0x66 else 'BAD'})")
              print(f"  Satellite   : {sat_id.decode(errors='replace')}  ({sat_id.hex()})")
              print(f"  VC          : {vc}  ({vc_label})")
              print(f"  Flags+VC    : 0x{flags_vc:02X}  "
                    f"[HAS_PAYLOAD={has_payload} ARQ_ON={arq_on} HAS_AUTH={has_auth} VC={vc}]")
              print(f"  Frame seq   : {seq}  (0x{seq:04X})")
              print(f"  Ext hdr len : {ext_len}")
              if clean_ext:
                  print(f"  Ext header  : {clean_ext.hex()}")
              if clean_payload:
                  print(f"  Payload     : {len(clean_payload)} bytes")
                  for off in range(0, len(clean_payload), 16):
                      chunk = clean_payload[off:off+16]
                      h = " ".join(f"{b:02X}" for b in chunk)
                      a = "".join(chr(b) if 32 <= b < 127 else "." for b in chunk)
                      print(f"    [{off:03d}]  {h:<47}  {a}")
              if clean_auth:
                  print(f"  Auth (8B)   : {clean_auth.hex()}")
              print(f"  RS FEC (32B): {de255[self.DAT_BYTES:].hex()}")
              err_str = f"{n_errors} bit error(s) corrected" if n_errors else "no errors"
              print(f"  Golay       : 0x{golay_raw:06X}  data12={data12} -> {data_len} clean bytes  [{err_str}]")
              print(f"  Clean frame : {clean_frame!r}")
              print(SEP)

              self._clean_frames.append(clean_frame)
              out_path = os.path.join(self.out_dir, "clean_frames.bin")
              with open(out_path, "wb") as f:
                  for cf in self._clean_frames:
                      f.write(len(cf).to_bytes(2, "big") + cf)
              print(f"  >> Wrote {len(self._clean_frames)} frame(s) to {out_path}", flush=True)

          def work(self, input_items, output_items):
              bits = input_items[0].astype(np.uint8) & 1
              if not len(bits):
                  return 0

              self._buf.extend(bits.tolist())
              self._trim_buf()

              rel = max(0, self._search_abs - self._abs0)

              while True:
                  asm_rel = self._find_asm(rel)
                  if asm_rel < 0:
                      break

                  g_start = asm_rel + self.ASM_LEN
                  c_start = g_start + self.GOLAY_LEN

                  golay_bits = self._buf[g_start:g_start + self.GOLAY_LEN]
                  cw_bits    = self._buf[c_start:c_start + self._cw_bits]

                  if len(golay_bits) < self.GOLAY_LEN or len(cw_bits) < self._cw_bits:
                      print(f"[reject] short buffer after ASM @ bit {self._abs0 + asm_rel}")
                      break

                  def reject(reason):
                      nonlocal rel
                      print(f"[reject] ASM @ bit {self._abs0 + asm_rel}: {reason}")
                      rel = asm_rel + 1
                      self._search_abs = self._abs0 + rel

                  golay_raw = self._bits_to_int(golay_bits)
                  try:
                      data12, n_errors = _golay24_decode(golay_raw)
                  except GolayUncorrectable:
                      reject("Golay uncorrectable")
                      continue

                  data_len = data12 - self.RS_BYTES
                  if not (1 <= data_len <= self.DAT_BYTES):
                      reject(f"bad data_len={data_len}")
                      continue

                  raw255 = self._pack_msb(cw_bits)
                  de255  = self._dewhiten(raw255)

                  if de255[:7] != self.MAGIC:
                      reject(f"bad magic {de255[:7].hex()}")
                      continue

                  if (11 + de255[8]) > self.DAT_BYTES:
                      reject(f"ext_len too large: ext_len={de255[8]}")
                      continue

                  key = zlib.crc32(raw255) & 0xFFFFFFFF
                  if key in self._seen:
                      reject("duplicate frame")
                      continue
                  self._seen.add(key)

                  self._emit(de255, golay_raw, data12, n_errors, self._abs0 + asm_rel)
                  rel = asm_rel + 1
                  self._search_abs = self._abs0 + rel

              return len(input_items[0])
    out_dir: '''home/groundstation-user/Documents/GNU-Radio-Flow-Graphs/Skylink'''
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      import csv
      import json
      import sys
      from datetime import datetime, timezone

      import os
      import zlib
      import numpy as np
      from gnuradio import gr

      SERVICE_LABELS = {
          (1, 7):  "TC Verification: Execution Completion",
          (3, 2):  "OBC Housekeeping",
          (3, 3):  "EPS Housekeeping",
          (3, 4):  "ADCS Housekeeping",
          (3, 5):  "UHF Housekeeping",
          (3, 6):  "Deployment Housekeeping",
          (4, 4):  "Event",
          (6, 8):  "File Transfer Init",
          (6, 13): "File Transfer Block",
      }

      VC_LABELS = {
          0: "VC0",
          1: "VC1",
          2: "VC2",
          3: "Ham Repeater",
      }


      def safe_dt(ts: int) -> str:
          try:
              return datetime.fromtimestamp(ts, tz=timezone.utc).isoformat()
          except Exception:
              return ""


      def u32be(b: bytes, off: int) -> int:
          return int.from_bytes(b[off:off+4], "big", signed=False)


      def read_frames_from_csv(csv_path: str):
          rows = []
          with open(csv_path, newline="", encoding="utf-8") as f:
              reader = csv.DictReader(f)
              for row in reader:
                  hx = (row.get("frame_hex") or "").strip()
                  if not hx:
                      continue
                  try:
                      frame = bytes.fromhex(hx)
                  except Exception:
                      continue
                  rows.append((row, frame))
          return rows


      def find_service_marker(frame: bytes):
          known = set(SERVICE_LABELS.keys())
          for i in range(len(frame) - 2):
              if frame[i] != 0x10:
                  continue
              st = frame[i + 1]
              sst = frame[i + 2]
              if (st, sst) in known:
                  return {
                      "marker_off": i,
                      "service": st,
                      "subtype": sst,
                      "payload_off": i + 3,
                  }
          return None


      def classify_frame(frame: bytes):
          row = {
              "frame_len": len(frame),
              "proto_ok": len(frame) >= 7 and frame[:7] == b"fOH2F1S",
              "protocol_id": "",
              "satellite_id_ascii": "",
              "satellite_id_hex": "",
              "flags_vc": "",
              "vc": "",
              "vc_label": "",
              "seq_le": "",
              "service_type": "",
              "service_subtype": "",
              "label": "",
              "pus_marker_off": "",
              "hk_unix_time": "",
              "hk_utc": "",
              "header_preview_hex": frame[:24].hex(),
              "service_payload_hex": "",
              "frame_hex": frame.hex(),
          }

          if len(frame) < 11:
              return row

          proto = frame[0]
          sat_id = frame[1:7]
          flags_vc = frame[7]
          vc = flags_vc & 0x07

          # Sequence is little-endian in these frames:
          # 96 05 -> 1430, 97 05 -> 1431, etc.
          seq_le = frame[9] | (frame[10] << 8)

          row["protocol_id"] = f"0x{proto:02X}"
          row["satellite_id_ascii"] = sat_id.decode("ascii", errors="replace")
          row["satellite_id_hex"] = sat_id.hex()
          row["flags_vc"] = f"0x{flags_vc:02X}"
          row["vc"] = vc
          row["vc_label"] = VC_LABELS.get(vc, f"VC{vc}")
          row["seq_le"] = seq_le

          # Special case: Ham repeater traffic on VC=3
          if vc == 3:
              row["label"] = "Ham Repeater"
              return row

          pus = find_service_marker(frame)
          if pus is None:
              row["label"] = row["vc_label"]
              return row

          service = pus["service"]
          subtype = pus["subtype"]

          row["service_type"] = service
          row["service_subtype"] = subtype
          row["label"] = SERVICE_LABELS.get((service, subtype), row["vc_label"])
          row["pus_marker_off"] = pus["marker_off"]

          payload = frame[pus["payload_off"]:]
          row["service_payload_hex"] = payload.hex()

          # Housekeeping timestamp begins immediately after 10 / service / subtype
          if len(payload) >= 4:
              ts = u32be(payload, 0)
              if 1600000000 <= ts <= 2000000000:
                  row["hk_unix_time"] = ts
                  row["hk_utc"] = safe_dt(ts)

          return row


      def write_outputs(rows, out_base):
          csv_path = out_base + "_classified.csv"
          jsonl_path = out_base + "_classified.jsonl"

          fieldnames = [
              "index",
              "frame_len",
              "proto_ok",
              "protocol_id",
              "satellite_id_ascii",
              "satellite_id_hex",
              "flags_vc",
              "vc",
              "vc_label",
              "seq_le",
              "service_type",
              "service_subtype",
              "label",
              "pus_marker_off",
              "hk_unix_time",
              "hk_utc",
              "header_preview_hex",
              "service_payload_hex",
              "frame_hex",
          ]

          with open(csv_path, "w", newline="", encoding="utf-8") as f:
              writer = csv.DictWriter(f, fieldnames=fieldnames)
              writer.writeheader()
              for row in rows:
                  writer.writerow(row)

          with open(jsonl_path, "w", encoding="utf-8") as f:
              for row in rows:
                  f.write(json.dumps(row, sort_keys=False) + "\n")

          return csv_path, jsonl_path


      def main():
          if len(sys.argv) != 2:
              print("Usage: python3 parse_clean_frames_final.py clean_frames_parsed.csv")
              sys.exit(1)

          in_csv = sys.argv[1]
          frames = read_frames_from_csv(in_csv)

          rows = []
          for i, (_, frame) in enumerate(frames, start=1):
              row = classify_frame(frame)
              row["index"] = i
              rows.append(row)

          out_base = in_csv.rsplit(".", 1)[0]
          csv_path, jsonl_path = write_outputs(rows, out_base)

          print(f"Frames read    : {len(rows)}")
          print(f"CSV written    : {csv_path}")
          print(f"JSONL written  : {jsonl_path}")

          by_label = {}
          by_vc = {}
          for r in rows:
              lbl = r["label"] or "Unclassified"
              by_label[lbl] = by_label.get(lbl, 0) + 1

              vc_lbl = r["vc_label"] or "Unknown VC"
              by_vc[vc_lbl] = by_vc.get(vc_lbl, 0) + 1

          print("\nCounts by VC:")
          for k in sorted(by_vc):
              print(f"  {k}: {by_vc[k]}")

          print("\nCounts by label:")
          for k in sorted(by_label):
              print(f"  {k}: {by_label[k]}")

          print("\nFirst few rows:")
          for r in rows[:10]:
              print(
                  f"idx={r['index']} "
                  f"seq={r['seq_le']} "
                  f"vc={r['vc']} ({r['vc_label']}) "
                  f"type={r['service_type']}/{r['service_subtype']} "
                  f"label={r['label']} "
                  f"time={r['hk_utc']}"
              )


      if __name__ == "__main__":
          main()
    out_dir: '''home/groundstation-user/Documents/GNU-Radio-Flow-Graphs/Skylink'''
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '4'
    taps: 'True'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 125000 + tune_shift
    decim: '20'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 6000, 2000, window.WIN_BLACKMAN_HARRIS)
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '14000'
    decim: '1'
    gain: '1'
    samp_rate: '50000'
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: '24000'
    fc: '0'
    fftsize: '1024'
    plotconst: 'False'
    plottime: 'False'
    rate: '32'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    type: ccc
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: name
    iq: 'True'
    name: FORESAIL-1P
    samp_rate: '96000'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: demod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: demod
  states: {}

connections:
- [analog_agc2_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_agc2_xx_0, '0', fir_filter_xxx_0, '0']
- [analog_agc2_xx_0, '0', satellites_satellite_decoder_0, '0']
- [analog_agc_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_agc_xx_0, '0', low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0, '0', virtual_sink_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0, '0']
- [digital_binary_slicer_fb_1, '0', epy_block_0, '0']
- [digital_binary_slicer_fb_1, '0', epy_block_1, '0']
- [digital_binary_slicer_fb_1, '0', epy_block_1_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_1, '0']
- [fir_filter_xxx_0, '0', qtgui_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc2_xx_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_0, print]
- [virtual_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
